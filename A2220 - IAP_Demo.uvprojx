# Keil uVision project A2220 - IAP_Demo.uvprojx, settings and files
target A2220 - IAP_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HAL_Demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\App;.\CMSIS;.\Core;.\HAL_lib\STM32F1xx_HAL_Driver\Inc;.\HAL_lib\STM32F1xx_HAL_Driver\Inc\Legacy;.\User;.\Sys;.\IAP
  memory RVCT4: ROM 0x8000000 size 0x5c00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group HAL_lib
    ./HAL_lib/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_iwdg.c
  group Core
    ./Core/: cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group CMSIS
    ./CMSIS/: stm32f1xx.h stm32f103xb.h system_stm32f1xx.c system_stm32f1xx.h startup_stm32f103xb.s
  group Sys
    ./Sys/: mydelay.c mydelay.h mysys.c mysys.h uart.c uart.h
  group User
    ./User/: main.c stm32f1xx_hal_conf.h stm32f1xx_hal_msp.c stm32f1xx_it.c stm32f1xx_it.h
  group App
    ./App/: mytemp.c mytemp.h R485.c R485.h update.c update.h flash.c flash.h
  group IAP
    ./IAP/: IAP.c IAP.h
  group ReadMe
    ./: ReadMe.txt
